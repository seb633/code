# Keil uVision project GD32F303.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F303 +hex
  AfterMake: fromelf.exe --bin --output .\INV_01_001_001.bin  .\Objects\GD32F303.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F30X_HD,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM,
  c include: .\CMSIS;.\MCU;.\GD32F30x_standard_peripheral\Include;.\App;.\Arch;.\FreeRTOS\include;.\FreeRTOS\Port;.\config;.\App\standard;.\Jscope\Config;.\Jscope\RTT
  memory RVCT4: ROM 0x8005000 size 0x3a800
  memory RVCT9: RAM 0x20000000 size 0xbf00
  group CMSIS
    ./CMSIS/: system_gd32f30x.c startup_gd32f30x_hd.s
  group Standard_peripheral
    ./GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group MCU
    ./MCU/: gd32f30x_it.c systick.c
  group App
    ./App/: main.cpp appTaskOs.cpp func.cpp isrtime.cpp variable.cpp sample.cpp rated.cpp PIController.cpp faultChk.cpp dataCalc.cpp piecewise.cpp ntc.cpp worklogic.cpp mppt.cpp buckboost.cpp multistate.cpp protocol.cpp flashSave.cpp
    ./App/standard/: standard.cpp
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group OS-Port
    ./FreeRTOS/Port/: port.c
  group Arch
    ./Arch/: arch.cpp uartDrv.cpp
  group Jscope
    ./Jscope/Config/: SEGGER_RTT_Conf.h
    ./Jscope/RTT/: SEGGER_RTT.c SEGGER_RTT.h
software components: CMSIS:DSP 1.5.2
